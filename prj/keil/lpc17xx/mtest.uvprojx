# Keil uVision project mtest.uvprojx, settings and files
target mTest (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mtest
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CM3;..\..\..\os\lpc17xx\uCOS-II\Ports;..\..\..\os\lpc17xx\uCOS-II\Source;..\..\..\fw\inc;.\LPC17xx;.\LPC17xx\Startup;..\..\..\fw_app\lpc17xx\inc;..\..\..\adapter\inc;..\..\..\ftp;.\Drivers
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\Tool\mdev.sct
  group Startup
    ./LPC17xx/Startup/: startup_LPC17xx.s
    ./LPC17xx/: LPC17xx.h system_LPC17xx.c system_LPC17xx.h
  group user
    ./usr/: main.c
  group fw
    ../../../fw/src/: mcrc.c mdev.c
  group fw_app
    ../../../fw_app/lpc17xx/src/: mdev_app.c mrec_app.c
  group ftp
    ../../../ftp/: xmodem_r.c
  group Drivers
    ./Drivers/: uart0.c
